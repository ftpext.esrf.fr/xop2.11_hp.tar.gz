wav1.dat
 20     100
 4.1      40.1
 60        0.5
9786565
 .3     0     0
 .1    -.1   .3
 .1    -.1   .3
 0     0     0
 0     0     0
 0     0     0
 .3   .03    .05
 0     0     0
 0     0     0
 .3     .2   .05
 0     0     0
 0     0     0
 .5    .2    .1
 0     0     0
 0     0     0
 .2     .1    .05
 .2    .1     .05
 .2    .1     .05
 .9     .1    .2
 0     0     0
 0     0     0
 0     0     0
 0     0     0
 0     0     0
 .4    .01   .1
 0     0     0
 0     0     0
 .4    .03   .1
 0     0     0
 0     0     0
 0     0     0
 .6    .02   .2
 .6    .02   .2
 0     0     0
 .4    .1    .1
 .4    .1    .1
 0     0     0
.4     .1    .1
.4     .1    .1
 .1     0     0
 .4    .1    .1
 .4    .1    .1
 .1     0     0
 .2     0     0
 .2     0     0
  0     0     0
 .2    .3   .1
 .2    .3   .1
 0     0     0
 .3    .2   .2
 .3    .2   .2
 0     0     0
 0    .2    .1
 0    .2    .1
 0     0     0
 0    .2    .1
 0    .2    .1
 0     0     0
 0     0     0
 0     0     0
 0     0     0
