wav_test1.dat
 16     100
 4.1      40.1
 0        0.5
9786565
 1.0     0     0