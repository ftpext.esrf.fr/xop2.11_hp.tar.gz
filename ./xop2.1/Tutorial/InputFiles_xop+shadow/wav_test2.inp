wav_test2.dat
 16     100
 4.1      40.1
 5        0.5
9786565
 0.0     0     0
 0.0     0     0
 0.0     0     0
 0.0     0     0
 0.0     0     0
 1.0     0     0